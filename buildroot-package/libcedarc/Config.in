## buildroot-package/libcedarc/Config.in
```kconfig
config BR2_PACKAGE_LIBCEDARC
    bool "libcedarc"
    help
        Allwinner Cedar Video Engine Library
```
